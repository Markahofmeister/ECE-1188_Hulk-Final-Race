# IAR project CC3100BOOST_MQTT-TwitterLED_MSP432P401R.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MSP432P401R TexasInstruments MSP432P401R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __MSP432P401R__; ewarm; _USE_CLI_
  ICCARM.CCIncludePath2: ..; ..\board; ..\cli_uart; ..\driverlib\MSP432P4xx; ..\mqtt; ..\simplelink\include; ..\simplelink\source; ..\spi_cc3100; ..\uart_cc3100; $TOOLKIT_DIR$\inc\TexasInstruments; $TOOLKIT_DIR$\inc\TexasInstruments\CMSIS; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c README.txt sl_common.h
    ./: startup_msp432p401r_ewarm.c system_msp432p401r.c
  group board
    ../board/: board.c board.h
  group cli_uart
    ../cli_uart/: cli_uart.c cli_uart.h
  group driverlib/MSP432P4xx
    ../driverlib/MSP432P4xx/: adc14.c adc14.h aes256.c aes256.h comp_e.c comp_e.h cpu.c cpu.h crc32.c crc32.h cs.c cs.h debug.h dma.c dma.h driverlib.h eusci.h flash.c flash.h fpu.c fpu.h gpio.c gpio.h i2c.c i2c.h interrupt.c interrupt.h mpu.c mpu.h pcm.c pcm.h pmap.c pmap.h pss.c pss.h ref_a.c ref_a.h reset.c reset.h rom.h rom_map.h rtc_c.c rtc_c.h spi.c spi.h sysctl.c sysctl.h systick.c systick.h timer32.c timer32.h timer_a.c timer_a.h uart.c uart.h wdt_a.c wdt_a.h
  group mqtt
    ../mqtt/: MQTTCC3100.c MQTTCC3100.h MQTTClient.c MQTTClient.h MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
  group simplelink
    ../simplelink/: README.txt template_user.h
  group simplelink/include
    ../simplelink/include/: device.h fs.h netapp.h netcfg.h simplelink.h socket.h trace.h user.h wlan.h wlan_rx_filters.h
  group simplelink/source
    ../simplelink/source/: device.c driver.c driver.h flowcont.c flowcont.h fs.c netapp.c netcfg.c nonos.c nonos.h objInclusion.h protocol.h socket.c spawn.c spawn.h wlan.c
  group spi_cc3100
    ../spi_cc3100/: spi_cc3100.c spi_cc3100.h
  group uart_cc3100
    ../uart_cc3100/: uart_cc3100.c uart_cc3100.h
