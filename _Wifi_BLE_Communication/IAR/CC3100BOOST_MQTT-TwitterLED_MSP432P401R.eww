<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CC3100BOOST_MQTT-TwitterLED_MSP432P401R.ewp</path>
  </project>
  <batchBuild/>
</workspace>


